# IAR project TamiyaTank.ewp, settings and files
configuration L2A6 (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMC21J18A Microchip ATSAMC21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DONT_USE_CMSIS_INIT; __SAMC21J18A__
  ICCARM.CCIncludePath2: src; src\headers; ..\..\xdk-asf-3.49.1\thirdparty\CMSIS\Include; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\component; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\instance; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\include\pio; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\source\; ..\..\xdk-asf-3.49.1\sam0\utils\cmsis\samc21\source\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TamiyaTank.srec
  ILINK.IlinkOutputFile: TamiyaTank.out
  ILINK.IlinkIcfFile: TamiyaTank.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../../xdk-asf-3.49.1/sam0/utils/cmsis/samc21/source/iar/: startup_samc21.c
  group cmsis/include
    ../../xdk-asf-3.49.1/sam0/utils/cmsis/samc21/include/: samc21.h samc21j18a.h
  group cmsis/include/instance
    ../../xdk-asf-3.49.1/sam0/utils/cmsis/samc21/include/instance/: ac.h adc0.h adc1.h can0.h can1.h ccl.h dac.h divas.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h hmatrixhs.h mclk.h mtb.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pm.h port.h rstc.h rtc.h sdadc.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h supc.h tal.h tc0.h tc1.h tc2.h tc3.h tc4.h tcc0.h tcc1.h tcc2.h tsens.h wdt.h
  group header
    src/headers/: Gpio.h Gsensor.h I2cMaster.h Initialize.h Motor.h Receiver.h Servo.h TamiyaTank.h
  group src
    src/: Gpio.c I2cMaster.c Isr.c IsrPpmMeasure.c IsrPwmGen.c Main.c Motor.c Receiver.c SystemHandler.c Tick.c
  group src/Init
    src/: Initialize.c InitializePpmMeasure.c InitializeTimers.c
